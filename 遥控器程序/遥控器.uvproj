# Keil uVision project 遥控器.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: 遥控器 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\INC
  group Source Group 1
    ./SRC/: main.c NRF24L01.c time.c
    ./INC/: time.h
