# Keil uVision project 智能车桩.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: 智能车桩 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\inc
  group Source Group 1
    ./scr/: main.c motor.c timer0.c oled.c NRF24L01.c GP2Y_ADC.c usart1.c usart2.c progress.c
    ./inc/: project_config.h
